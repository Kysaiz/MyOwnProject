# Keil uVision project demo.uvprojx, settings and files
target Project1 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\RTE;..\RTE\Device\STM32F407ZE;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart1;..\SYSTEM\usart3;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\AS608;..\HARDWARE\DHT11;..\HARDWARE\FLASH;..\HARDWARE\IWDG;..\HARDWARE\KEYBOARD;..\HARDWARE\Mifare522;..\HARDWARE\OLED;..\HARDWARE\RTC;..\HARDWARE\TIM;..\HARDWARE\USART2;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/KEYBOARD/: keyboard.c
    ../HARDWARE/Mifare522/: Mifare522.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart1/: usart1.c
    ../SYSTEM/usart3/: usart3.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
