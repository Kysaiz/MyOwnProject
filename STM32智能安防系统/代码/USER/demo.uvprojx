# Keil uVision project demo.uvprojx, settings and files
target Project1 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\RTE;..\RTE\Device\STM32F407ZE;..\SYSTEM\delay;..\SYSTEM\usart1;..\SYSTEM\usart3;..\HARDWARE\BEEP;..\HARDWARE\DHT11;..\HARDWARE\IWDG;..\HARDWARE\KEYBOARD;..\HARDWARE\LED;..\SYSTEM\sys;..\HARDWARE\TIM;..\HARDWARE\sr04
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/KEYBOARD/: keyboard.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/sr04/: sr04.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart1/: usart1.c
    ../SYSTEM/usart3/: usart3.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
